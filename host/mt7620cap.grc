options:
  parameters:
    author: Neucom Info
    category: Custom
    description: MT7620 PBF capture from an mt7620agent node over ZMQ
    generate_options: qt_gui
    id: mt7620cap
    output_language: python
    title: MT7620 capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Advertised by the node in each capture record header.
    value: '20000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Channel centre the node was tuned to (ch1 = 2412 MHz).
    value: '2412000000'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    comment: host/mt7620cap.py --tcp <node>:5555 --zmq tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '5'
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
